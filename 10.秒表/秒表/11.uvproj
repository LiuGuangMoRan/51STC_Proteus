# Keil uVision project 11.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 11 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Timer0.c Timer0.h I2C.c I2C.h Better_Nixie.c Better_Nixie.h Better_Small_Key.h Better_Small_Key.c
